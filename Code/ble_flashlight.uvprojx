# Keil uVision project ble_flashlight.uvprojx, settings and files
target nrf52810_xxaa (5060960::V5.06 update 7 (build 960)::.\ARM_Compiler_5.06u7)
  device: nRF52810_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.40.3
  cpu: IRAM(0x20000000,0x00006000) IRAM2(0x00800000,0x00006000) IROM(0x00000000,0x00030000) CPUTYPE("Cortex-M4") DSP CLOCK(12000000) ELITTLE
  output: nrf52810_xxaa +hex
  c flags: Optim=4 OneElfS=1 uC99=1
  c define: APP_TIMER_V2 APP_TIMER_V2_RTC1_ENABLED BOARD_NHW003 CONFIG_GPIO_AS_PINRESET DEVELOP_IN_NRF52810 FLOAT_ABI_SOFT NRF52810_XXAA NRF52_PAN_74 NRF_SD_BLE_API_VERSION=7 S112 SOFTDEVICE_PRESENT DEBUG FLOAT_ABI_HARD NRF_LOG_USES_RTT=1 __HEAP_SIZE=2048 __STACK_SIZE=2048
  c misc: --reduce_paths
  c include: config;\src\nRF5_SDK_17.1.0\components;src\nRF5_SDK_17.1.0\components\ble\ble_advertising;src\nRF5_SDK_17.1.0\components\ble\ble_dtm;src\nRF5_SDK_17.1.0\components\ble\ble_racp;src\nRF5_SDK_17.1.0\components\ble\ble_services\ble_ancs_c;src\nRF5_SDK_17.1.0\components\ble\ble_services\ble_ans_c;src\nRF5_SDK_17.1.0\components\ble\ble_services\ble_bas;src\nRF5_SDK_17.1.0\components\ble\ble_services\ble_bas_c;src\nRF5_SDK_17.1.0\components\ble\ble_services\ble_cscs;src\nRF5_SDK_17.1.0\components\ble\ble_services\ble_cts_c;src\nRF5_SDK_17.1.0\components\ble\ble_services\ble_dfu;src\nRF5_SDK_17.1.0\components\ble\ble_services\ble_dis;src\nRF5_SDK_17.1.0\components\ble\ble_services\ble_gls;src\nRF5_SDK_17.1.0\components\ble\ble_services\ble_hids;src\nRF5_SDK_17.1.0\components\ble\ble_services\ble_hrs;src\nRF5_SDK_17.1.0\components\ble\ble_services\ble_hrs_c;src\nRF5_SDK_17.1.0\components\ble\ble_services\ble_hts;src\nRF5_SDK_17.1.0\components\ble\ble_services\ble_ias;src\nRF5_SDK_17.1.0\components\ble\ble_services\ble_ias_c;src\nRF5_SDK_17.1.0\components\ble\ble_services\ble_lls;src\nRF5_SDK_17.1.0\components\ble\ble_services\ble_nus;src\nRF5_SDK_17.1.0\components\ble\ble_services\ble_nus_c;src\nRF5_SDK_17.1.0\components\ble\ble_services\ble_rscs;src\nRF5_SDK_17.1.0\components\ble\ble_services\ble_rscs_c;src\nRF5_SDK_17.1.0\components\ble\ble_services\ble_tps;src\nRF5_SDK_17.1.0\components\ble\common;src\nRF5_SDK_17.1.0\components\ble\nrf_ble_gatt;src\nRF5_SDK_17.1.0\components\ble\nrf_ble_qwr;src\nRF5_SDK_17.1.0\components\ble\peer_manager;src\nRF5_SDK_17.1.0\components\boards;src\nRF5_SDK_17.1.0\components\libraries\atomic;src\nRF5_SDK_17.1.0\components\libraries\atomic_fifo;src\nRF5_SDK_17.1.0\components\libraries\atomic_flags;src\nRF5_SDK_17.1.0\components\libraries\balloc;src\nRF5_SDK_17.1.0\components\libraries\bootloader\ble_dfu;src\nRF5_SDK_17.1.0\components\libraries\button;src\nRF5_SDK_17.1.0\components\libraries\cli;src\nRF5_SDK_17.1.0\components\libraries\crc16;src\nRF5_SDK_17.1.0\components\libraries\crc32;src\nRF5_SDK_17.1.0\components\libraries\crypto;src\nRF5_SDK_17.1.0\components\libraries\csense;src\nRF5_SDK_17.1.0\components\libraries\csense_drv;src\nRF5_SDK_17.1.0\components\libraries\delay;src\nRF5_SDK_17.1.0\components\libraries\ecc;src\nRF5_SDK_17.1.0\components\libraries\experimental_section_vars;src\nRF5_SDK_17.1.0\components\libraries\experimental_task_manager;src\nRF5_SDK_17.1.0\components\libraries\fds;src\nRF5_SDK_17.1.0\components\libraries\fstorage;src\nRF5_SDK_17.1.0\components\libraries\gfx;src\nRF5_SDK_17.1.0\components\libraries\gpiote;src\nRF5_SDK_17.1.0\components\libraries\hardfault;src\nRF5_SDK_17.1.0\components\libraries\hci;src\nRF5_SDK_17.1.0\components\libraries\led_softblink;src\nRF5_SDK_17.1.0\components\libraries\log;src\nRF5_SDK_17.1.0\components\libraries\log\src;src\nRF5_SDK_17.1.0\components\libraries\low_power_pwm;src\nRF5_SDK_17.1.0\components\libraries\mem_manager;src\nRF5_SDK_17.1.0\components\libraries\memobj;src\nRF5_SDK_17.1.0\components\libraries\mpu;src\nRF5_SDK_17.1.0\components\libraries\mutex;src\nRF5_SDK_17.1.0\components\libraries\pwm;src\nRF5_SDK_17.1.0\components\libraries\pwr_mgmt;src\nRF5_SDK_17.1.0\components\libraries\queue;src\nRF5_SDK_17.1.0\components\libraries\ringbuf;src\nRF5_SDK_17.1.0\components\libraries\scheduler;src\nRF5_SDK_17.1.0\components\libraries\sdcard;src\nRF5_SDK_17.1.0\components\libraries\slip;src\nRF5_SDK_17.1.0\components\libraries\sortlist;src\nRF5_SDK_17.1.0\components\libraries\spi_mngr;src\nRF5_SDK_17.1.0\components\libraries\stack_guard;src\nRF5_SDK_17.1.0\components\libraries\strerror;src\nRF5_SDK_17.1.0\components\libraries\svc;src\nRF5_SDK_17.1.0\components\libraries\timer;src\nRF5_SDK_17.1.0\components\libraries\twi_mngr;src\nRF5_SDK_17.1.0\components\libraries\twi_sensor;src\nRF5_SDK_17.1.0\components\libraries\usbd;src\nRF5_SDK_17.1.0\components\libraries\usbd\class\audio;src\nRF5_SDK_17.1.0\components\libraries\usbd\class\cdc;src\nRF5_SDK_17.1.0\components\libraries\usbd\class\cdc\acm;src\nRF5_SDK_17.1.0\components\libraries\usbd\class\hid;src\nRF5_SDK_17.1.0\components\libraries\usbd\class\hid\generic;src\nRF5_SDK_17.1.0\components\libraries\usbd\class\hid\kbd;src\nRF5_SDK_17.1.0\components\libraries\usbd\class\hid\mouse;src\nRF5_SDK_17.1.0\components\libraries\usbd\class\msc;src\nRF5_SDK_17.1.0\components\libraries\util;src\nRF5_SDK_17.1.0\components\softdevice\common;src\nRF5_SDK_17.1.0\components\softdevice\s112\headers;src\nRF5_SDK_17.1.0\components\softdevice\s112\headers\nrf52;src\nRF5_SDK_17.1.0\external\fprintf;src\nRF5_SDK_17.1.0\external\segger_rtt;src\nRF5_SDK_17.1.0\external\utf_converter;src\nRF5_SDK_17.1.0\integration\nrfx;src\nRF5_SDK_17.1.0\integration\nrfx\legacy;src\nRF5_SDK_17.1.0\modules\nrfx;src\nRF5_SDK_17.1.0\modules\nrfx\drivers\include;src\nRF5_SDK_17.1.0\modules\nrfx\hal;src\lib;src\lib\Battery_level;src\lib\app;src\
  asm define: APP_TIMER_V2 APP_TIMER_V2_RTC1_ENABLED BOARD_NHW003 CONFIG_GPIO_AS_PINRESET DEVELOP_IN_NRF52832 FLOAT_ABI_SOFT NRF52810_XXAA NRF52_PAN_74 NRFX_COREDEP_DELAY_US_LOOP_CYCLES=3 NRF_SD_BLE_API_VERSION=7 S112 SOFTDEVICE_PRESENT __HEAP_SIZE=2048 __STACK_SIZE=2048
  asm misc: --cpreproc_opts=-DAPP_TIMER_V2,-DAPP_TIMER_V2_RTC1_ENABLED,-DBOARD_PCA10040,-DCONFIG_GPIO_AS_PINRESET,-DDEVELOP_IN_NRF52832,-DFLOAT_ABI_SOFT,-DNRF52810_XXAA,-DNRF52_PAN_74,-DNRFX_COREDEP_DELAY_US_LOOP_CYCLES=3,-DNRF_SD_BLE_API_VERSION=7,-DS112,-DSOFTDEVICE_PRESENT,-D__HEAP_SIZE=2048,-D__STACK_SIZE=2048
  asm include: ..\..\..\config;src\nRF5_SDK_17.1.0\components;src\nRF5_SDK_17.1.0\components\ble\ble_advertising;src\nRF5_SDK_17.1.0\components\ble\ble_dtm;src\nRF5_SDK_17.1.0\components\ble\ble_racp;src\nRF5_SDK_17.1.0\components\ble\ble_services\ble_ancs_c;src\nRF5_SDK_17.1.0\components\ble\ble_services\ble_ans_c;src\nRF5_SDK_17.1.0\components\ble\ble_services\ble_bas;src\nRF5_SDK_17.1.0\components\ble\ble_services\ble_bas_c;src\nRF5_SDK_17.1.0\components\ble\ble_services\ble_cscs;src\nRF5_SDK_17.1.0\components\ble\ble_services\ble_cts_c;src\nRF5_SDK_17.1.0\components\ble\ble_services\ble_dfu;src\nRF5_SDK_17.1.0\components\ble\ble_services\ble_dis;src\nRF5_SDK_17.1.0\components\ble\ble_services\ble_gls;src\nRF5_SDK_17.1.0\components\ble\ble_services\ble_hids;src\nRF5_SDK_17.1.0\components\ble\ble_services\ble_hrs;src\nRF5_SDK_17.1.0\components\ble\ble_services\ble_hrs_c;src\nRF5_SDK_17.1.0\components\ble\ble_services\ble_hts;src\nRF5_SDK_17.1.0\components\ble\ble_services\ble_ias;src\nRF5_SDK_17.1.0\components\ble\ble_services\ble_ias_c;src\nRF5_SDK_17.1.0\components\ble\ble_services\ble_lbs;src\nRF5_SDK_17.1.0\components\ble\ble_services\ble_lbs_c;src\nRF5_SDK_17.1.0\components\ble\ble_services\ble_lls;src\nRF5_SDK_17.1.0\components\ble\ble_services\ble_nus;src\nRF5_SDK_17.1.0\components\ble\ble_services\ble_nus_c;src\nRF5_SDK_17.1.0\components\ble\ble_services\ble_rscs;src\nRF5_SDK_17.1.0\components\ble\ble_services\ble_rscs_c;src\nRF5_SDK_17.1.0\components\ble\ble_services\ble_tps;src\nRF5_SDK_17.1.0\components\ble\common;src\nRF5_SDK_17.1.0\components\ble\nrf_ble_gatt;src\nRF5_SDK_17.1.0\components\ble\nrf_ble_qwr;src\nRF5_SDK_17.1.0\components\ble\peer_manager;src\nRF5_SDK_17.1.0\components\boards;src\nRF5_SDK_17.1.0\components\libraries\atomic;src\nRF5_SDK_17.1.0\components\libraries\atomic_fifo;src\nRF5_SDK_17.1.0\components\libraries\atomic_flags;src\nRF5_SDK_17.1.0\components\libraries\balloc;src\nRF5_SDK_17.1.0\components\libraries\bootloader\ble_dfu;src\nRF5_SDK_17.1.0\components\libraries\button;src\nRF5_SDK_17.1.0\components\libraries\cli;src\nRF5_SDK_17.1.0\components\libraries\crc16;src\nRF5_SDK_17.1.0\components\libraries\crc32;src\nRF5_SDK_17.1.0\components\libraries\crypto;src\nRF5_SDK_17.1.0\components\libraries\csense;src\nRF5_SDK_17.1.0\components\libraries\csense_drv;src\nRF5_SDK_17.1.0\components\libraries\delay;src\nRF5_SDK_17.1.0\components\libraries\ecc;src\nRF5_SDK_17.1.0\components\libraries\experimental_section_vars;src\nRF5_SDK_17.1.0\components\libraries\experimental_task_manager;src\nRF5_SDK_17.1.0\components\libraries\fds;src\nRF5_SDK_17.1.0\components\libraries\fstorage;src\nRF5_SDK_17.1.0\components\libraries\gfx;src\nRF5_SDK_17.1.0\components\libraries\gpiote;src\nRF5_SDK_17.1.0\components\libraries\hardfault;src\nRF5_SDK_17.1.0\components\libraries\hci;src\nRF5_SDK_17.1.0\components\libraries\led_softblink;src\nRF5_SDK_17.1.0\components\libraries\log;src\nRF5_SDK_17.1.0\components\libraries\log\src;src\nRF5_SDK_17.1.0\components\libraries\low_power_pwm;src\nRF5_SDK_17.1.0\components\libraries\mem_manager;src\nRF5_SDK_17.1.0\components\libraries\memobj;src\nRF5_SDK_17.1.0\components\libraries\mpu;src\nRF5_SDK_17.1.0\components\libraries\mutex;src\nRF5_SDK_17.1.0\components\libraries\pwm;src\nRF5_SDK_17.1.0\components\libraries\pwr_mgmt;src\nRF5_SDK_17.1.0\components\libraries\queue;src\nRF5_SDK_17.1.0\components\libraries\ringbuf;src\nRF5_SDK_17.1.0\components\libraries\scheduler;src\nRF5_SDK_17.1.0\components\libraries\sdcard;src\nRF5_SDK_17.1.0\components\libraries\slip;src\nRF5_SDK_17.1.0\components\libraries\sortlist;src\nRF5_SDK_17.1.0\components\libraries\spi_mngr;src\nRF5_SDK_17.1.0\components\libraries\stack_guard;src\nRF5_SDK_17.1.0\components\libraries\strerror;src\nRF5_SDK_17.1.0\components\libraries\svc;src\nRF5_SDK_17.1.0\components\libraries\timer;src\nRF5_SDK_17.1.0\components\libraries\twi_mngr;src\nRF5_SDK_17.1.0\components\libraries\twi_sensor;src\nRF5_SDK_17.1.0\components\libraries\usbd;src\nRF5_SDK_17.1.0\components\libraries\usbd\class\audio;src\nRF5_SDK_17.1.0\components\libraries\usbd\class\cdc;src\nRF5_SDK_17.1.0\components\libraries\usbd\class\cdc\acm;src\nRF5_SDK_17.1.0\components\libraries\usbd\class\hid;src\nRF5_SDK_17.1.0\components\libraries\usbd\class\hid\generic;src\nRF5_SDK_17.1.0\components\libraries\usbd\class\hid\kbd;src\nRF5_SDK_17.1.0\components\libraries\usbd\class\hid\mouse;src\nRF5_SDK_17.1.0\components\libraries\usbd\class\msc;src\nRF5_SDK_17.1.0\components\libraries\util;src\nRF5_SDK_17.1.0\components\softdevice\common;src\nRF5_SDK_17.1.0\components\softdevice\s112\headers;src\nRF5_SDK_17.1.0\components\softdevice\s112\headers\nrf52;src\nRF5_SDK_17.1.0\external\fprintf;src\nRF5_SDK_17.1.0\external\segger_rtt;src\nRF5_SDK_17.1.0\external\utf_converter;src\nRF5_SDK_17.1.0\integration\nrfx;src\nRF5_SDK_17.1.0\integration\nrfx\legacy;src\nRF5_SDK_17.1.0\modules\nrfx;src\nRF5_SDK_17.1.0\modules\nrfx\drivers\include;src\nRF5_SDK_17.1.0\modules\nrfx\hal;..\config
  library: MicroLIB
  memory RVCT4: ROM 0x19000 size 0x17000
  memory RVCT9: RAM 0x20001ae0 size 0x4520
  memory RVCT10: RAM 0x800000 size 0x6000
  link misc: --diag_suppress 6330
  group Application
    src/: main.c
    config/: sdk_config.h
    src/lib/Battery_level/: Battery_level.c
    src/lib/app/: app_ble.c handles.c
    src/lib/: parameters.h ble_torch_s.c utils.h
  group Board Definition
    src/: board_config.h
  group UTF8/UTF16 converter
    src/nRF5_SDK_17.1.0/external/utf_converter/: utf.c
  group nRF_BLE
    src/nRF5_SDK_17.1.0/components/ble/common/: ble_advdata.c ble_conn_params.c ble_conn_state.c ble_srv_common.c
    src/nRF5_SDK_17.1.0/components/ble/nrf_ble_gatt/: nrf_ble_gatt.c
    src/nRF5_SDK_17.1.0/components/ble/nrf_ble_qwr/: nrf_ble_qwr.c
  group nRF_Drivers
    src/nRF5_SDK_17.1.0/modules/nrfx/drivers/src/: nrfx_adc.c nrfx_saadc.c nrfx_clock.c nrfx_gpiote.c nrfx_uart.c nrfx_uarte.c nrfx_twi.c nrfx_twim.c nrfx_ppi.c nrfx_timer.c
    src/nRF5_SDK_17.1.0/integration/nrfx/legacy/: nrf_drv_clock.c nrf_drv_uart.c nrf_drv_twi.c nrf_drv_ppi.c
    src/nRF5_SDK_17.1.0/modules/nrfx/soc/: nrfx_atomic.c
    src/nRF5_SDK_17.1.0/modules/nrfx/drivers/src/prs/: nrfx_prs.c
  group nRF_Libraries
    src/nRF5_SDK_17.1.0/components/libraries/button/: app_button.c
    src/nRF5_SDK_17.1.0/components/libraries/util/: app_error.c app_error_handler_keil.c app_error_weak.c app_util_platform.c nrf_assert.c
    src/nRF5_SDK_17.1.0/components/libraries/scheduler/: app_scheduler.c
    src/nRF5_SDK_17.1.0/components/libraries/timer/: app_timer2.c drv_rtc.c
    src/nRF5_SDK_17.1.0/components/libraries/hardfault/: hardfault_implementation.c
    src/nRF5_SDK_17.1.0/components/libraries/atomic_fifo/: nrf_atfifo.c
    src/nRF5_SDK_17.1.0/components/libraries/atomic_flags/: nrf_atflags.c
    src/nRF5_SDK_17.1.0/components/libraries/atomic/: nrf_atomic.c
    src/nRF5_SDK_17.1.0/components/libraries/balloc/: nrf_balloc.c
    src/nRF5_SDK_17.1.0/external/fprintf/: nrf_fprintf.c nrf_fprintf_format.c
    src/nRF5_SDK_17.1.0/components/libraries/memobj/: nrf_memobj.c
    src/nRF5_SDK_17.1.0/components/libraries/pwr_mgmt/: nrf_pwr_mgmt.c
    src/nRF5_SDK_17.1.0/components/libraries/ringbuf/: nrf_ringbuf.c
    src/nRF5_SDK_17.1.0/components/libraries/experimental_section_vars/: nrf_section_iter.c
    src/nRF5_SDK_17.1.0/components/libraries/sortlist/: nrf_sortlist.c
    src/nRF5_SDK_17.1.0/components/libraries/strerror/: nrf_strerror.c
    src/nRF5_SDK_17.1.0/components/libraries/pwm/: app_pwm.c
  group nRF_Log
    src/nRF5_SDK_17.1.0/components/libraries/log/src/: nrf_log_backend_rtt.c nrf_log_backend_serial.c nrf_log_backend_uart.c nrf_log_default_backends.c nrf_log_frontend.c nrf_log_str_formatter.c
  group nRF_Segger_RTT
    src/nRF5_SDK_17.1.0/external/segger_rtt/: SEGGER_RTT.c SEGGER_RTT_Syscalls_KEIL.c SEGGER_RTT_printf.c
  group nRF_SoftDevice
    src/nRF5_SDK_17.1.0/components/softdevice/common/: nrf_sdh.c nrf_sdh_ble.c nrf_sdh_soc.c
target flash_s112_nrf52_7.2.0_softdevice (5060960::V5.06 update 7 (build 960)::.\ARM_Compiler_5.06u7)
  device: nRF52805_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.44.1
  cpu: as above
  output: s112_nrf52_7.2.0_softdevice.hex +hex
  BeforeMake: attrib +R $H\*
  c flags: Optim=4 OneElfS=1 uC99=1
  c define: __HEAP_SIZE=2048 __STACK_SIZE=2048
  c misc: --reduce_paths
  c include: ..\..\..\config;..\config
  asm define: __HEAP_SIZE=2048 __STACK_SIZE=2048
  asm misc: --cpreproc_opts=-D__HEAP_SIZE=2048,-D__STACK_SIZE=2048
  asm include: ..\..\..\config;..\config
  library: MicroLIB
  memory RVCT4: ROM 0x19000 size 0x17000
  memory RVCT9: RAM 0x20001ae0 size 0x4520
  memory RVCT10: RAM 0x800000 size 0x6000
  link misc: --diag_suppress 6330
software components: CMSIS:CORE 5.3.0, CMSIS:CORE 5.6.0, Device:Startup 8.44.1, Device:Startup 8.40.3
